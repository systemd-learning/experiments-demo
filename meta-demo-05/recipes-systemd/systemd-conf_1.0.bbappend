FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = "file://wired.network"